# Keil uVision project PROJECT.uvprojx, settings and files
target Target 1 (5050169::V5.05 update 2 (build 169)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PROJECT
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU6050,EMPL_TARGET_STM32F1
  c include: ..\User;..\Libraries\AHT30;..\Libraries\BEEP;..\Libraries\cJSON;..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\Libraries\IIC;..\Libraries\KEY;..\Libraries\LED;..\Libraries\SPI;..\Libraries\SysTick;..\Libraries\TIM;..\Libraries\UART;..\Libraries\NET\device\inc;..\Libraries\NET\MQTT;..\Libraries\NET\onenet\inc;..\Libraries\OLED;..\Libraries\TFT_LCD;..\Libraries\DMA;..\Libraries\EXTI;..\Libraries\CAN;..\Libraries\MPU6050;..\Libraries\MPU6050\Middlewares\driver;..\Libraries\MPU6050\Middlewares\eMPL-hal;..\Libraries\MPU6050\Middlewares\mllite;..\Libraries\MPU6050\Middlewares\mpl;..\Libraries\MPU6050\Middlewares\porting;..\Libraries\MPU6050\Middlewares\driver\eMPL;..\Libraries\MPU6050\Middlewares\driver\include;..\Libraries\MPU6050\Middlewares\driver\stm32L;..\Libraries\HC_SR04;..\Libraries\MOTOR;..\Libraries\GPIO
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c
  group LIBRARIES
    ../Libraries/LED/: bsp_led.c
    ../Libraries/KEY/: bsp_key.c
    ../Libraries/UART/: bsp_usart.c
    ../Libraries/SPI/: bsp_spi.c
    ../Libraries/EXTI/: bsp_exti.c
    ../Libraries/IIC/: bsp_soft_i2c.c bsp_iic.c bsp_hard_i2c.c
    ../Libraries/SysTick/: bsp_SysTick.c
    ../Libraries/OLED/: oled.c
    ../Libraries/TFT_LCD/: bsp_TFT_Font.c
    ../Libraries/TIM/: bsp_pwm.c bsp_tim.c bsp_encoder.c
    ../Libraries/HC_SR04/: bsp_hc_sr04.c
    ../Libraries/MOTOR/: bsp_520Motor.c bsp_control.c
    ../Libraries/GPIO/: bsp_gpio.c
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group MPU6050
    ../Libraries/MPU6050/: mpu6050.c
    ../Libraries/MPU6050/Middlewares/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../Libraries/MPU6050/Middlewares/mpl/: libmpllib.lib
    ../Libraries/MPU6050/Middlewares/driver/stm32L/: log_stm32.c
    ../Libraries/MPU6050/Middlewares/porting/: mpu6050_SL.c
    ../Libraries/MPU6050/Middlewares/mllite/: data_builder.c mpl.c hal_outputs.c ml_math_func.c storage_manager.c results_holder.c message_layer.c start_manager.c
    ../Libraries/MPU6050/Middlewares/eMPL-hal/: eMPL_outputs.c
